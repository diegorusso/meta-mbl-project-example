inherit mbl-distro-image

SUMMARY = "Example image based on Mbed Linux OS - diegor"
DESCRIPTION = "A minimal image containing MBL and the void"
HOMEPAGE = "http://www.diegor.uk"

IMAGE_INSTALL_append = " zsh"